# Keil uVision project stm32f407_usb_storage_mass.uvprojx, settings and files
target stm32f407_usb_storage_mass (6120000::V6.12::.\ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f407_usb_storage_mass +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;                                                                                                    ../USB_DEVICE/App;                                                                                                    ../USB_DEVICE/Target;                                                                                                    ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                                    ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                                    ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                                                    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;                                                                                                    ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                                    ../Drivers/CMSIS/Include;                                                                                                    ..\BSP\inc;                                                                                              ../FATFS/Target;                                                                                              ../FATFS/App;                                                                                              ../Middlewares/Third_Party/FatFs/src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dcmi.c dma.c fsmc.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/BSP
    ../BSP/src/: bsp_w25qxx.c bsp_sram.c bsp_led.c bsp_lcd.c bsp_ov7670.c bsp_at24cxx.c bsp_delay.c bsp_color_convert.c bsp_sccb.c bsp_button.c bsp_enc28j60.c bsp_comm.c bsp_nrf24lxx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
